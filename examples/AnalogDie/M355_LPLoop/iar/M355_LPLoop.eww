<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\M355_LPLoop.ewp</path>
    </project>
    <batchBuild />
</workspace>
