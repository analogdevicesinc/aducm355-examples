<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\M355_ECSns_CycloVoltammetry.ewp</path>
    </project>
    <batchBuild />
</workspace>
