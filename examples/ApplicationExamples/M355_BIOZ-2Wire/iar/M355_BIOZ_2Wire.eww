<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\M355_BIOZ_2Wire.ewp</path>
    </project>
    <batchBuild />
</workspace>
