# IAR project M355_BIOZ_2Wire.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM355 AnalogDevices ADUCM355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CHIPSEL_M355; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: ..\..\..\..\common\IAR; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ILINK.IlinkOutputFile: M355_BIOZ_2Wire.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ARM/config/linker/AnalogDevices/ADuCM355.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCOptLevel: 3
  group app
    ../: AD5940Main.c BIOZ-2Wire.c main.c
    ./: README_M355_BIOZ_2Wire.txt
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device Retarget UART
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/IAR/: retarget.c
  group CMSIS-Pack/Device Startup
    RTE/Device/ADuCM355/: adi_config.h startup_ADuCM355.c system_ADuCM355.c
  group CMSIS-Pack/Device.AFE Operation
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/ad5940lib/: ad5940.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: ADuCM355Port.c
  group CMSIS-Pack/Device.Peripheral Libraries CLOCK
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: ClkLib.c
  group CMSIS-Pack/Device.Peripheral Libraries GPIO
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: DioLib.c
  group CMSIS-Pack/Device.Peripheral Libraries INT
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: IntLib.c
  group CMSIS-Pack/Device.Peripheral Libraries PWR
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: PwrLib.c
  group CMSIS-Pack/Device.Peripheral Libraries UART
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: UrtLib.c
  group CMSIS-Pack/Device.Peripheral Libraries Watchdog
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: AfeWdtLib.c
