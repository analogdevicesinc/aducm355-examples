# IAR project M355_RadiatedImmunity_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM355 AnalogDevices ADUCM355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CHIPSEL_M355; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: ..\..\..\..\common\IAR; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ILINK.IlinkOutputFile: M355_RadiatedImmunity_Demo.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ARM/config/linker/AnalogDevices/ADuCM355.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ADuCM355 AnalogDevices ADuCM355
  ICCARM.CCOptLevel: 3
  group app
    ../: AD5940Main.c M355_EMCFlash.c main.c RadiatedImmunity_Demo.c
    ./: README_M355_Radiatedlmmunity_Demo.txt
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device Retarget UART
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/IAR/: retarget.c
  group CMSIS-Pack/Device Startup
    RTE/Device/ADuCM355/: adi_config.h startup_ADuCM355.c system_ADuCM355.c
  group CMSIS-Pack/Device.AFE Operation
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/ad5940lib/: ad5940.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: ADuCM355Port.c
  group CMSIS-Pack/Device.Peripheral Libraries CLOCK
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: ClkLib.c
  group CMSIS-Pack/Device.Peripheral Libraries FLASH
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: FeeLib.c
  group CMSIS-Pack/Device.Peripheral Libraries GPIO
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: DioLib.c
  group CMSIS-Pack/Device.Peripheral Libraries INT
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: IntLib.c
  group CMSIS-Pack/Device.Peripheral Libraries PWR
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: PwrLib.c
  group CMSIS-Pack/Device.Peripheral Libraries UART
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: UrtLib.c
