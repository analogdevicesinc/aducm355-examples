<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\M356_ECSns_EIS\M356_ECSns_EIS.ewp</path>
    </project>
    <batchBuild />
</workspace>
