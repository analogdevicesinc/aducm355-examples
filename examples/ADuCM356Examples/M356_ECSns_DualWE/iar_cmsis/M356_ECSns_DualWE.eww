<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\M356_ECSns_DualWE\M356_ECSns_DualWE.ewp</path>
    </project>
    <batchBuild />
</workspace>
