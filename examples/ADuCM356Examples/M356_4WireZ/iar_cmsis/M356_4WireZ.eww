<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\M356_4WireZ\M356_4WireZ.ewp</path>
    </project>
    <batchBuild />
</workspace>
