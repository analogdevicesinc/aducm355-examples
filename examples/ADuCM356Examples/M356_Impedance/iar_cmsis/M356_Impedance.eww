<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\M356_Impedance\M356_Impedance.ewp</path>
    </project>
    <batchBuild />
</workspace>
