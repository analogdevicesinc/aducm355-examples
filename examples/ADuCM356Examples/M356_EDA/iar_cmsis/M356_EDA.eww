<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\M356_EDA\M356_EDA.ewp</path>
    </project>
    <batchBuild />
</workspace>
