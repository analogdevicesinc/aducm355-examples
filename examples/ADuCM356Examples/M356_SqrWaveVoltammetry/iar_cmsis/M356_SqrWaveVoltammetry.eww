<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\M356_SqrWaveVoltammetry\M356_SqrWaveVoltammetry.ewp</path>
    </project>
    <batchBuild />
</workspace>
