<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\M356_ECSns_SingleWE\M356_ECSns_SingleWE.ewp</path>
    </project>
    <batchBuild />
</workspace>
