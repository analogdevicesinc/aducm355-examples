<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\user-bootloader\M355_User_Bootloader.ewp</path>
  </project>
  <batchBuild/>
</workspace>


