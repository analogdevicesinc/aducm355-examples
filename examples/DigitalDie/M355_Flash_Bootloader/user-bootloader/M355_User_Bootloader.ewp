# IAR project M355_User_Bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM355 AnalogDevices ADUCM355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: M355_User_Bootloader.hex
  ILINK.IlinkOutputFile: M355_User_Bootloader.out
  ILINK.IlinkIcfFile: iar\user-bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ADuCM355 AnalogDevices ADuCM355
  ICCARM.CCDefines: CHIPSEL_M355; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group app
    ./: README_M355_Flash_Bootloader.txt user-bootloader.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device.Peripheral Libraries I2C
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: I2cLib.c
  group CMSIS-Pack/Device.Peripheral Libraries UART
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: UrtLib.c
  group CMSIS-Pack/Device.Peripheral Libraries CLOCK
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: ClkLib.c
  group CMSIS-Pack/Device.Peripheral Libraries CRC
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: CrcLib.c
  group CMSIS-Pack/Device.Peripheral Libraries GPIO
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: DioLib.c
