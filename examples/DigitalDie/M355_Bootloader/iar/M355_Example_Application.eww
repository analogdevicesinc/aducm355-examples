<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\M355_Example_Application.ewp</path>
    </project>
    <batchBuild />
</workspace>
