# IAR project M355_I2C_Master.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM355 AnalogDevices ADUCM355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CHIPSEL_M355; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: M355_I2C_Master.srec
  ILINK.IlinkOutputFile: M355_I2C_Master.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\AnalogDevices\ADuCM355.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: M355_CRC.srec
  group app
    ../: M355_I2C_Master.c
    ./: README_M355_I2C_Master.txt
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device Retarget UART
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/IAR/: retarget.c
  group CMSIS-Pack/Device Startup
    RTE/Device/ADuCM355/: adi_config.h startup_ADuCM355.c system_ADuCM355.c
  group CMSIS-Pack/Device.AFE Operation
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/ad5940lib/: ad5940.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: ADuCM355Port.c
  group CMSIS-Pack/Device.Peripheral Libraries CLOCK
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: ClkLib.c
  group CMSIS-Pack/Device.Peripheral Libraries CRC
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: CrcLib.c
  group CMSIS-Pack/Device.Peripheral Libraries GPIO
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: DioLib.c
  group CMSIS-Pack/Device.Peripheral Libraries I2C
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: I2cLib.c
  group CMSIS-Pack/Device.Peripheral Libraries INT
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: IntLib.c
  group CMSIS-Pack/Device.Peripheral Libraries UART
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM355_DFP#2.1.0}$/ADuCM355/common/: UrtLib.c
